# IAR project STM32F030F4_Demo.ewp, settings and files
configuration STM32F0308_Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030F4 ST STM32F030F4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32F0308-Discovery; ..\..\..\BSP
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F030F4_Demo.srec
  ILINK.IlinkOutputFile: STM32F0308-Discovery_Demo.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    $EW_DIR$/workspace/mems/BSP/: KEY.c LED.c mems.c USART1.c
  group CMSIS
    ../: system_stm32f0xx.c
  group EWARM
    $EW_DIR$/workspace/mems/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group STM32F0xx_StdPeriph_Driver
    $EW_DIR$/workspace/mems/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ../: main.c stm32f0xx_it.c
